<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\aws_demos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>aws_demos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aws_demos</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


