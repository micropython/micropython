<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cmock_demo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>cmock_demo</project>
        <configuration>Binary</configuration>
      </member>
      <member>
        <project>cmock_demo</project>
        <configuration>FLASH_Debug</configuration>
      </member>
      <member>
        <project>cmock_demo</project>
        <configuration>RAM_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


