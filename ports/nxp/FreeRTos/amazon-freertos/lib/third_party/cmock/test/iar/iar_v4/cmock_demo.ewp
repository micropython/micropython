# IAR project cmock_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCIncludePath2: ..\..\examples\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: incIAR
  XLINK.XclFile: Resource\at91SAM7X256_FLASH.xcl
configuration Simulate (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SIMULATE
configuration Release (ARM)
  as the first configuration, except:
  group Resource
    Resource/: at91SAM7X256_FLASH.xcl at91SAM7X256_RAM.xcl SAM7_FLASH.mac SAM7_RAM.mac SAM7_SIM.mac
  group Source
    ../../examples/src/: AdcConductor.c AdcHardware.c AdcHardwareConfigurator.c AdcModel.c AdcTemperatureSensor.c Executor.c IntrinsicsWrapper.c Main.c Model.c TaskScheduler.c TemperatureCalculator.c TemperatureFilter.c TimerConductor.c TimerConfigurator.c TimerHardware.c TimerInterruptConfigurator.c TimerInterruptHandler.c TimerModel.c UsartBaudRateRegisterCalculator.c UsartConductor.c UsartConfigurator.c UsartHardware.c UsartModel.c UsartPutChar.c UsartTransmitBufferStatus.c
  group Startup
    srcIAR/: Cstartup.s79 Cstartup_SAM7.c
