# IAR project cmock_demo.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCIncludePath2: ..\..\examples\src; incIAR
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: incIAR
  OBJCOPY.OOCOutputFile: cmock_demo.srec
  ILINK.IlinkOutputFile: cmock_demo.out
  ILINK.IlinkIcfFile: Resource\at91SAM7X256_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\examples\src\; incIAR
  ILINK.IlinkIcfFile: Resource\at91SAM7X256_FLASH.icf
configuration Binary (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\examples\src; srcIAR; incIAR
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: cmock_demo.hex
  ILINK.IlinkIcfFile: Resource\at91SAM7X256_FLASH.icf
  group Resource
    Resource/: at91SAM7X256_FLASH.icf at91SAM7X256_RAM.icf SAM7_FLASH.mac SAM7_RAM.mac
  group Source
    ../../examples/src/: AdcConductor.c AdcHardware.c AdcHardwareConfigurator.c AdcModel.c AdcTemperatureSensor.c Executor.c IntrinsicsWrapper.c Main.c Model.c TaskScheduler.c TemperatureCalculator.c TemperatureFilter.c TimerConductor.c TimerConfigurator.c TimerHardware.c TimerInterruptConfigurator.c TimerInterruptHandler.c TimerModel.c UsartBaudRateRegisterCalculator.c UsartConductor.c UsartConfigurator.c UsartHardware.c UsartModel.c UsartPutChar.c UsartTransmitBufferStatus.c
  group Startup
    srcIAR/: Cstartup.s Cstartup_SAM7.c
